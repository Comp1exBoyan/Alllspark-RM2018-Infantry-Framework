# Keil uVision project Robomaster_ZZ.uvprojx, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Robomaster_ZZ +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\Lib;..\MLib;..\MLib\DiPan;..\MLib\FreeCars;..\MLib\IMU;..\MLib\IWDG;..\MLib\Math;..\MLib\SBUS;..\MLib\Weapeon;..\MLib\YunTai;..\User;..\MLib\Driver;..\freertos\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DiPan
    ../MLib/DiPan/: can1.c dipanint.c dipanctl.c
  group YunTai
    ../MLib/YunTai/: can2.c yuntaiint.c yuntaictl.c
  group User
    ../User/: main.c stm32f4xx_it.c scheduler.c init.c
  group Driver
    ../MLib/Driver/: delay.c iwdg.c key.c led.c SBUS.c JudgeSystemN.c usart3.c
  group Weapon
    ../MLib/Weapeon/: Weapon.c IntelligentFight.h
  group Lib
    ../Lib/: misc.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_iwdg.c stm32f4xx_i2c.c stm32f4xx_spi.c startup_stm32f427xx.s system_stm32f4xx.c
  group IMU
    ../MLib/IMU/: ahrs.c imu.c imuint.c IST8310.c mpu6500.c mpu6500_spi.c mpu9250.c
  group Math
    ../MLib/Math/: filter.c mymath.c Pid_Regulator.c motor.c
  group freeRTOS
    ../freertos/src/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
software components: CMSIS:CORE 5.0.1
